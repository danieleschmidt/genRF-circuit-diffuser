* lc_vco - Generated by GenRF Generation 1
* Target: 10.00GHz, 0dB gain, infdB NF

.param vdd=1.2
.param temp=27

* LC VCO
M1 outp outn tail bulk nch W=5.359e-05 L=1.337e-07
M2 outn outp tail bulk nch W=5.359e-05 L=1.337e-07

L1 outp vdd 1.568e-08
L2 outn vdd 1.568e-08
C1 outp outn 2.262e-12

Ibias tail 0 DC 8.439e-03
Vdd vdd 0 DC 1.2

.model nch nmos level=1
.end
