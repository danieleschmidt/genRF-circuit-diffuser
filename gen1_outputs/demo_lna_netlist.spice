* Simple Cascode LNA - Generated by GenRF
* Operating frequency: 2.40 GHz

.subckt simple_lna vin vout vdd vss
* Input matching network
L1 vin n1 1.93n
C1 n1 n2 4.16p

* First stage (common source)
M1 n3 n2 vss vss nmos w=43.5u l=180n
Rbias1 vdd n2 48k
Cbypass1 n2 vss 90p

* Second stage (cascode)
M2 vout n4 n3 vss nmos w=44.1u l=180n
Rbias2 vdd n4 23k

* Load resistor
Rload vout vdd 8.1k

* Output matching
L2 vout n5 0.51n
C2 n5 0 1.72p

.ends simple_lna
