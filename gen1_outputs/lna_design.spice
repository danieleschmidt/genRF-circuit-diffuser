* cascode_lna - Generated by GenRF Generation 1
* Target: 2.40GHz, 15dB gain, 1.5dB NF

.param vdd=1.2
.param temp=27

* LNA Core Circuit
M1 n1 input source bulk nch W=9.586e-05 L=4.658e-07
M2 output vbias n1 bulk nch W=1.782e-05 L=2.382e-07

* Matching Networks
Ls input n2 7.724e-09
Lg n2 gate 7.620e-09
Ld output n3 5.598e-09

* Biasing
Vbias vbias 0 DC 0.925
Ibias source 0 DC 7.594e-03

* Supply
Vdd vdd 0 DC 1.2

.model nch nmos level=1
.end
