* Simple Cascode LNA - Generated by GenRF
* Operating frequency: 2.40 GHz

.subckt simple_lna vin vout vdd vss
* Input matching network
L1 vin n1 0.93n
C1 n1 n2 2.41p

* First stage (common source)
M1 n3 n2 vss vss nmos w=43.0u l=180n
Rbias1 vdd n2 19k
Cbypass1 n2 vss 40p

* Second stage (cascode)
M2 vout n4 n3 vss nmos w=58.5u l=180n
Rbias2 vdd n4 70k

* Load resistor
Rload vout vdd 7.7k

* Output matching
L2 vout n5 1.02n
C2 n5 0 2.60p

.ends simple_lna
